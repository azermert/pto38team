# Keil uVision project PTO_project_STM32F3.uvproj, settings and files
target PTO_STM32F3-DISCOVERY (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: processor_code +hex
  c flags: Optim=1
  c define: STM32F30X, USE_STDPERIPH_DRIVER
  c include: .\inc;..\common\src;..\common\inc;.\lib;.\lib\CMSIS\Include;.\lib\CMSIS\Device\ST\STM32F30x\Include;.\lib\STM32F30x_StdPeriph_Driver\inc;.\lib\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group inc
    ./inc/: adc.h buttons.h dac.h gpio_ext.h gpio_in.h gpio_out.h lcd.h led.h nmi_irq.h sys_ctl.h uart.h NVIC_Basic.h timeBase.h systemClock.h initialize.h typedefs.h
    ../common/inc/: abc.h
  group src
    ./src/: adc.c buttons.c dac.c gpio_ext.c gpio_in.c gpio_out.c lcd.c led.c nmi_irq.c sysctl.c uart.c main.c NVIC_Basic.c timeBase.c systemClock.c initialize.c
  group startup
    ./lib/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f30x.s
  group CMSIS
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.h
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h
  group lib
    ./lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group common
    ../common/src/: comm.c counter.c generator.c log_analyser.c scope.c state_automat.c parse_cmd.c
