# Keil uVision project prjNF.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: prjNF +hex
  c flags: Optim=1
  c define: STM32F0XX USE_STDPERIPH_DRIVER
  c include: .\lib\STM32F0xx_StdPeriph_Driver\inc;.\lib\STM32F0xx_StdPeriph_Driver\src;.\inc;..\project;.\src;.\lib;..\common\inc;..\common\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
  group src
    ./src/: adc.c dac.c gpio_in.c gpio_out.c uart.c main.c timeBase.c initialize.c systemClock.c NVIC_Basic.c gpio_ext.c
  group lib
    ./lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c system_stm32f0xx.c
  group common
    ../common/src/: comm.c counter.c generator.c log_analyser.c parse_cmd.c scope.c state_automat.c
