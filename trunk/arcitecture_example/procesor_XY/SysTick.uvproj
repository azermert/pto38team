# Keil uVision project SysTick.uvproj, settings and files
target STM32_Release (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: example +hex
  c flags: Optim=1
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartupCode
    ./: STM32F10x.s
  group Source
    ./src/: main.c uart.c nmi_irq.c
