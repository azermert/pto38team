# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: test
  c flags: Optim=1
  c include: ..\..\common\inc;..\inc;..\..\procesor_XY
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_stm32f10x_md.s
  group Source
    ../src/: uart.c adc.c dac.c gpio_ext.c gpio_in.c gpio_out.c nmi_irq.c
    ../../common/src/: comm.c scope.c generator.c log_analyser.c counter.c scpi.c
    ../: debug_main.c
  group Header
    ../inc/: uart.h
    ../../common/inc/: scpi.h comm.h scope.h generator.h
