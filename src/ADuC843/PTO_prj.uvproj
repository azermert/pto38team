# Keil uVision project PTO_prj.uvproj, settings and files
target PTO_prj (MCS-51)
  device: ADuC843 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(32768) DPX MODAB2
  output: PTO_prj
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ADuC843\lib;.\inc;.\common\inc;.\common\src;.\src
  group inc
    ./inc/: adc.h buttons.h dac.h gpio_ext.h gpio_in.h gpio_out.h lcd.h led.h nmi_irq.h sys_ctl.h uart.h NVIC_Basic.h timeBase.h systemClock.h initialize.h typedefs.h
    ../common/inc/: abc.h
  group src
    ./src/: adc.c buttons.c dac.c gpio_ext.c gpio_in.c gpio_out.c lcd.c led.c nmi_irq.c sysctl.c uart.c main.c NVIC_Basic.c timeBase.c systemClock.c initialize.c
  group common
    ./common/src/: comm.c counter.c generator.c log_analyser.c parse_cmd.c scope.c state_automat.c
