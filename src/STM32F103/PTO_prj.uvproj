# Keil uVision project PTO_prj.uvproj, settings and files
target PTO_prj (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: processor_code +hex
  c flags: Optim=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\inc;..\common\src;..\common\inc;.\lib;.\lib\CMSIS\CM3\CoreSupport;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\STM32F10x_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group inc
    ./inc/: adc.h buttons.h dac.h gpio_ext.h gpio_in.h gpio_out.h lcd.h led.h nmi_irq.h sys_ctl.h uart.h NVIC_Basic.h timeBase.h systemClock.h initialize.h
  group src
    ./src/: adc.c buttons.c dac.c gpio_ext.c gpio_in.c gpio_out.c lcd.c led.c nmi_irq.c sysctl.c uart.c main.c NVIC_Basic.c timeBase.c systemClock.c initialize.c
  group startup
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group CMSIS
    ./lib/CMSIS/CM3/CoreSupport/: core_cm3.h
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h
  group lib
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group common
    ../common/src/: comm.c counter.c generator.c log_analyser.c scope.c scpi.c state_automat.c
